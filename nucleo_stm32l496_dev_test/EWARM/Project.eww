<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\nucleo_stm32l496_dev_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
